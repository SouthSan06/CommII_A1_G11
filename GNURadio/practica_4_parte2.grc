options:
  parameters:
    generate_options: qt_gui
    id: practica_4_parte2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: bps
  id: variable
  parameters:
    value: math.log(M,2)
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: (0.77+0.77j, -0.77+0.77j, -0.77-0.77j, 0.77-0.77j)
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: int
    vector: (0, 1,  2, 3)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: int
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: import_0
  id: import
  parameters:
    imports: 'import math '
  states: {}

connections:
- [blocks_vector_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
