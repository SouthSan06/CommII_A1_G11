options:
  parameters:
    generate_options: qt_gui
    id: practica_4
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Constelacion
  id: variable
  parameters:
    value: (1+0j, 0+1j, -1+0j, 0-1j)
  states: {}
- name: M
  id: variable
  parameters:
    value: '4'
  states: {}
- name: N
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: Nbps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: Rb
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: Rs
  id: variable
  parameters:
    value: Rb/Nbps
  states: {}
- name: Sps
  id: variable
  parameters:
    value: len(h)
  states: {}
- name: h
  id: variable
  parameters:
    value: (1.,1.,1.,1.,1.,1.,1.,1.)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1.'
    type: float
  states: {state: disabled}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0.3'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: analog_random_source_x_0
  id: analog_random_source_x
  parameters:
    max: '2'
    min: '0'
    num_samps: '1000'
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_1
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 2*math.pi/M
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '[1/(N*samp_rate)]*N'
    type: float
    vlen: N
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: Nbps
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: Constelacion
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\n\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, example_param=1.0):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='VCO complex',   # will show up in GRC\n            in_sig=[np.float32,np.float32],\n            out_sig=[np.complex64]\n        )\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.example_param = example_param\n\n    def work(self, input_items, output_items):\n        Q=input_items[0]\n        A=input_items[1]\n        Sec=output_items[0]\n        Sec[:] = A*np.exp(1.j*Q)\n        return len(Sec)\n\n"
    example_param: '1.0'
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    N: N
    _source_code: |
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):  
          """vector averager. N is the lengh of the vector"""

          def __init__(self, N=1024):
              gr.sync_block.__init__(
                  self,
                  name='e_vec_averager_ff',   
                  in_sig=[(np.float32,N)],
                  out_sig=[(np.float32,N)]
              )
              self.N = N
              self.rows_counter=0
              self.sum=0

          def work(self, input_items, output_items):
              x=input_items[0]
              y=output_items[0]
              self.sum += np.sum(x, axis=0)
              self.rows_counter += len(x)
              y[:]=self.sum/self.rows_counter
              return len(output_items[0])
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccc
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: BINARY
    marker1: '0'
    size: '32'
    srate: Rb
    stemplot: 'True'
    type: float
    width1: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: M_PAM
    marker1: '0'
    size: int(32/Nbps)
    srate: Rs
    stemplot: 'True'
    type: float
    width1: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    label1: M-PAM-MOD
    marker1: '0'
    size: int(32/Nbps)
    srate: Rs
    stemplot: 'True'
    type: float
    width1: '3'
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    label1: EC-real
    label2: EC-ima
    marker1: '0'
    marker2: '0'
    size: int(32/Nbps)
    srate: Rs
    stemplot: 'True'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    label1: EC-real
    label2: EC-ima
    marker1: '0'
    marker2: '0'
    size: int(32/Nbps)
    srate: Rs
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    label1: EC-real
    size: int(32*Sps/Nbps)
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: '"PSD (Watts/Hz)"'
    vlen: N
    x_start: '-samp_rate/2'
    x_step: samp_rate/N
    ymax: 1/Rb
    ymin: '0'
  states: {state: disabled}

connections:
- [analog_const_source_x_0, '0', epy_block_0, '1']
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_noise_source_x_0, '0', qtgui_time_sink_x_1_0, '0']
- [analog_random_source_x_0, '0', blocks_char_to_float_0, '0']
- [analog_random_source_x_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_add_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_char_to_float_1, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', epy_block_1, '0']
- [blocks_multiply_const_vxx_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_1, '0']
- [blocks_repack_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_add_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [epy_block_0, '0', interp_fir_filter_xxx_0, '0']
- [epy_block_0, '0', qtgui_const_sink_x_0, '0']
- [epy_block_0, '0', qtgui_time_sink_x_1, '0']
- [epy_block_1, '0', blocks_multiply_const_vxx_1, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_stream_to_vector_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_throttle2_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [interp_fir_filter_xxx_0, '0', qtgui_time_sink_x_2, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
